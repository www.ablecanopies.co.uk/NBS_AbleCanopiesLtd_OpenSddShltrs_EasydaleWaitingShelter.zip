Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-04-30T17:29:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Apr 30 17:29:48 2020* Host: NCL-PI19* Database: C:\Users\MatukiNE\AppData\Local\Temp\{14597E5D-9BD8-4B72-85FE-E4A13EBF74BC}\ifc* Database version: 5507* Database creation date: Thu Apr 30 17:29:47 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Apr 30 17:29:47 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Apr 30 17:29:47 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: EasydaleWaitingShelter, NBS_AbleCanopiesLtd_OpenSddShltrs_EasydaleWaitingShelter:EasydaleWaitingShelter:192270
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_20_65_78_58 (Uniclass2015); Material: NBS_Concept, NBS_Plastic_Clear
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AbleCanopiesLtd_OpenSidedShelters_EasydaleWaitingShelter; ManufacturerName: Able Canopies Ltd; ManufacturerURL: www.ablecanopies.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/udz4tfmr; NBSDescription: Open sided shelters; NBSReference: 45-05-75/315; ProductInformation: https://www.ablecanopies.co.uk/shelters/waiting-shelters/easydale-waiting-shelter.html; Revision: n/a; Uniclass2015Title: Open sided shelters; Uniclass2015Code: Pr_20_65_78_58; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - FrameMaterial: NBS_Concept; FrameFinish: Powder coated; FrameColour: Any RAL colours; RoofCovering: n/a; OpeningsDoors: n/a; OpeningsWindows: n/a; OpeningsRoofVents: n/a; IntegralServices: n/a; RainwaterDrainage: n/a; Accessories: Cycle racks; Benches; Side Panels & Buggy Bar; Panels: 5 mm solid or 16 mm structed polycarbonate sheets in clear or opal; Guttering: n/a; WeatherResistance: Polycarbonate sheeting has alyer of UV absorber
Type - Pset_FurnitureTypeCommon - NominalDepth: 0 mm; Description: Cost effective shelter; MainColor: n/a; NominalHeight: 2200 mm; NominalLength: 4000 mm; Style: Shelter
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_65_78_58; Open sided shelters; CodePerformance: n/a; Color: www.ablecanopies.co.uk/colours-finishes.html; Constituents: n/a; DurationUnit: year; ExpectedLife: 25 years; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: sales@ablecanopies.co.uk; Material: n/a; ModelNumber: n/a; ModelReference: Easydale Waiting Shelter; Name: OpenSidedShelters_EasydaleWaitingShelter_AbleCanopiesLtd; NominalWidth: 1700 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - Category: Generic Models; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
